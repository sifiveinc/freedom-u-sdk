PACKAGES:remove = "${PN}-client"
PACKAGES:remove = "${PN}-server"

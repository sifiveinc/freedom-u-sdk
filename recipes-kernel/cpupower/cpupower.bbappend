INSANE_SKIP:${PN} += "installed-vs-shipped"

EXTRA_OECMAKE:append = " -DCMAKE_CXX_SCAN_FOR_MODULES=OFF"
